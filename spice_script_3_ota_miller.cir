OTA Miller Combined with the Beta-Multiplier (1.3 V)

*** ARQUIVOS DE MODELO ***
.include nmos130nm.pm
.include pmos130nm.pm

*** FONTES ***
vdd vdd 0 dc 1.3
vss vss 0 dc 0
vip vip 0 dc 0.65 ac 1
vin vin 0 dc 0.65

*** MOSFETS ***
*M  D  G   S   B
m01 x2 vin x5  vdd pmos w=16.799717u l=520.000000n
m02 x3 vip x5  vdd pmos w=16.799717u l=520.000000n
m03 x2 x2  vss vss nmos w=3.419261u l=520.000000n
m04 x3 x2  vss vss nmos w=3.419261u l=520.000000n
m05 x5 x1  vdd vdd pmos w=33.599434u l=520.000000n
m06 x4 x1  vdd vdd pmos w=16.799717u l=520.000000n
m07 x4 x3  vss vss nmos w=3.419261u l=520.000000n
m08 x1 x1  vdd vdd pmos w=33.599434u l=520.000000n
m09 x1 x8  vss vss nmos w=2.068322u l=520.000000n
m10 x8 x6  vdd vdd pmos w=2.547426u l=520.000000n
m11 x6 x6  vdd vdd pmos w=2.547446u l=520.000000n
m12 x8 x8  vss vss nmos w=0.517060u l=520.000000n
m13 x6 x8  x7  vss nmos w=0.517080u l=520.000000n

*** RESISTORES ***
rr x7 vss 37.000000k
rz x0 x4  312.000000k

*** CAPACITORES ***
cl x4 vss 2.000000p
cc x3 x0  0.500000p

*** ANALISE ***
.option temp=27
.control
ac dec 5000 1 1e12
run
set color0=white
set color1=black
set color2=black
set xbrushwidth=2
plot 20*log10(v(x4))
op
print v(vdd)*i(vdd)
print @m01[id]
print @m02[id]
print @m03[id]
print @m04[id]
print @m05[id]
print @m06[id]
print @m07[id]
print @m08[id]
print @m09[id]
print @m10[id]
print @m11[id]
print @m12[id]
print @m13[id]
print @m01[vds]-@m01[vdsat]
print @m02[vds]-@m02[vdsat]
print @m03[vds]-@m03[vdsat]
print @m04[vds]-@m04[vdsat]
print @m05[vds]-@m05[vdsat]
print @m06[vds]-@m06[vdsat]
print @m07[vds]-@m07[vdsat]
print @m08[vds]-@m08[vdsat]
print @m09[vds]-@m09[vdsat]
print @m10[vds]-@m10[vdsat]
print @m11[vds]-@m11[vdsat]
print @m12[vds]-@m12[vdsat]
print @m13[vds]-@m13[vdsat]
print @m13[vds]-@m13[vdsat]
.endc

.end
